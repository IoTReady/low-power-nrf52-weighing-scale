<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\pca10040e_ble\iar\secure_bootloader_ble_s112_pca10040e.ewp</path>
  </project>
  <batchBuild/>
</workspace>


