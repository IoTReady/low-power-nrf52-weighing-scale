# Keil uVision project secure_bootloader_ble_s112_pca10040e.uvprojx, settings and files
target nrf52832_xxaa_s112 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: nRF52810_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.16.0
  cpu: IRAM(0x20000000,0x6000) IROM(0x00000000,0x30000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: nrf52832_xxaa_s112 +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: FLOAT_ABI_SOFT DEVELOP_IN_NRF52832   NRF52810_XXAA APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BLE_STACK_SUPPORT_REQD BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET NRF52_PAN_74 NRF_DFU_SETTINGS_VERSION=1 NRF_DFU_SVCI_ENABLED NRF_SD_BLE_API_VERSION=6  SOFTDEVICE_PRESENT SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION __HEAP_SIZE=0 uECC_ENABLE_VLI_API=0 uECC_OPTIMIZATION_LEVEL=3 uECC_SQUARE_FUNC=0 uECC_SUPPORT_COMPRESSED_POINT=0 uECC_VLI_NATIVE_LITTLE_ENDIAN=1 S112
  c misc: --reduce_paths
  c include: ..\..\config\secure_bootloader_ble_s112_pca10040e;..\..\config;..\..\..\..\..\components\ble\common;..\..\..\..\..\components\boards;..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\components\libraries\atomic_fifo;..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\components\libraries\bootloader;..\..\..\..\..\components\libraries\bootloader\ble_dfu;..\..\..\..\..\components\libraries\bootloader\dfu;..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\components\libraries\crypto;..\..\..\..\..\components\libraries\crypto\backend\cc310;..\..\..\..\..\components\libraries\crypto\backend\cc310_bl;..\..\..\..\..\components\libraries\crypto\backend\cifra;..\..\..\..\..\components\libraries\crypto\backend\mbedtls;..\..\..\..\..\components\libraries\crypto\backend\micro_ecc;..\..\..\..\..\components\libraries\crypto\backend\nrf_hw;..\..\..\..\..\components\libraries\crypto\backend\nrf_sw;..\..\..\..\..\components\libraries\crypto\backend\oberon;..\..\..\..\..\components\libraries\delay;..\..\..\..\..\components\libraries\experimental_log;..\..\..\..\..\components\libraries\experimental_log\src;..\..\..\..\..\components\libraries\experimental_memobj;..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\components\libraries\queue;..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\components\libraries\sha256;..\..\..\..\..\components\libraries\sortlist;..\..\..\..\..\components\libraries\stack_info;..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\components\libraries\svc;..\..\..\..\..\components\libraries\timer;..\..\..\..\..\components\libraries\timer\experimental;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\softdevice\common;..\..\..\..\..\components\softdevice\s112\headers;..\..\..\..\..\components\softdevice\s112\headers\nrf52;..\..;..\..\..\..\..\external\micro-ecc\micro-ecc;..\..\..\..\..\external\nano-pb;..\..\..\..\..\integration\nrfx;..\..\..\..\..\modules\nrfx;..\..\..\..\..\modules\nrfx\hal;..\..\..\..\..\modules\nrfx\mdk;..\config
  asm define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BLE_STACK_SUPPORT_REQD BOARD_pca10040e CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_DFU_SETTINGS_VERSION=1 NRF_DFU_SVCI_ENABLED NRF_SD_BLE_API_VERSION=6 s112 SOFTDEVICE_PRESENT SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION __HEAP_SIZE=0 uECC_ENABLE_VLI_API=0 uECC_OPTIMIZATION_LEVEL=3 uECC_SQUARE_FUNC=0 uECC_SUPPORT_COMPRESSED_POINT=0 uECC_VLI_NATIVE_LITTLE_ENDIAN=1
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DBLE_STACK_SUPPORT_REQD,-DBOARD_pca10040e,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DNRF_DFU_SETTINGS_VERSION=1,-DNRF_DFU_SVCI_ENABLED,-DNRF_SD_BLE_API_VERSION=6,-Ds112,-DSOFTDEVICE_PRESENT,-DSVC_INTERFACE_CALL_AS_NORMAL_FUNCTION,-D__HEAP_SIZE=0,-DuECC_ENABLE_VLI_API=0,-DuECC_OPTIMIZATION_LEVEL=3,-DuECC_SQUARE_FUNC=0,-DuECC_SUPPORT_COMPRESSED_POINT=0,-DuECC_VLI_NATIVE_LITTLE_ENDIAN=1
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x28000 size 0x6000
  memory RVCT9: RAM 0x20002400 size 0x3c00
  link misc: --diag_suppress 6330
  group Application
    ../../../: dfu_public_key.c
    ../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../components/boards/: boards.c
  group nRF_BLE
    ../../../../../components/ble/common/: ble_srv_common.c
  group nRF_Bootloader
    ../../../../../components/libraries/bootloader/: nrf_bootloader.c nrf_bootloader_app_start.c nrf_bootloader_app_start_final.c nrf_bootloader_dfu_timers.c nrf_bootloader_fw_activation.c nrf_bootloader_info.c nrf_bootloader_wdt.c
  group nRF_Crypto
    ../../../../../components/libraries/crypto/: nrf_crypto_ecc.c nrf_crypto_ecdsa.c nrf_crypto_hash.c nrf_crypto_init.c nrf_crypto_shared.c
  group nRF_Crypto backend nRF sw
    ../../../../../components/libraries/crypto/backend/nrf_sw/: nrf_sw_backend_hash.c
  group nRF_Crypto backend uECC
    ../../../../../components/libraries/crypto/backend/micro_ecc/: micro_ecc_backend_ecc.c micro_ecc_backend_ecdh.c micro_ecc_backend_ecdsa.c
  group nRF_DFU
    ../../../../../components/libraries/bootloader/dfu/: dfu-cc.pb.c nrf_dfu.c nrf_dfu_flash.c nrf_dfu_handling_error.c nrf_dfu_mbr.c nrf_dfu_req_handler.c nrf_dfu_settings.c nrf_dfu_settings_svci.c nrf_dfu_transport.c nrf_dfu_utils.c nrf_dfu_validation.c nrf_dfu_ver_validation.c
    ../../../../../components/libraries/bootloader/ble_dfu/: nrf_dfu_ble.c
  group nRF_Drivers
    ../../../../../modules/nrfx/hal/: nrf_nvmc.c
  group nRF_Libraries
    ../../../../../components/libraries/util/: app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../components/libraries/timer/experimental/: app_timer2.c drv_rtc.c
    ../../../../../components/libraries/crc32/: crc32.c
    ../../../../../components/libraries/mem_manager/: mem_manager.c
    ../../../../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../../components/libraries/atomic/: nrf_atomic.c
    ../../../../../components/libraries/balloc/: nrf_balloc.c
    ../../../../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c nrf_fstorage_sd.c
    ../../../../../components/libraries/queue/: nrf_queue.c
    ../../../../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../../components/libraries/sortlist/: nrf_sortlist.c
    ../../../../../components/libraries/strerror/: nrf_strerror.c
    ../../../../../components/libraries/sha256/: sha256.c
  group nRF_SVC
    ../../../../../components/libraries/bootloader/dfu/: nrf_dfu_svci.c nrf_dfu_svci_handler.c
    ../../../../../components/libraries/svc/: nrf_svc_handler.c
  group nRF_SoftDevice
    ../../../../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group nRF_micro-ecc
    ../../../../../external/micro-ecc/nrf52nf_keil/armgcc/: micro_ecc_lib_nrf52.lib
  group nano-pb
    ../../../../../external/nano-pb/: pb_common.c pb_decode.c
target flash_s112_nrf52_6.0.0_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_InternalDeviceFamilyPack.8.9.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: s112_nrf52_6.0.0_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: __HEAP_SIZE=0
  c misc: --reduce_paths
  c include: ..\..\config\secure_bootloader_ble_s112_pca10040e;..\..\config;..\config
  asm define: __HEAP_SIZE=0
  asm misc: --cpreproc_opts=-D__HEAP_SIZE=0
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x78000 size 0x6000
  memory RVCT9: RAM 0x200057b8 size 0xa848
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 5.0.1, CMSIS:CORE 4.3.0, Device:Startup 8.16.0, Device:Startup 8.16.0
